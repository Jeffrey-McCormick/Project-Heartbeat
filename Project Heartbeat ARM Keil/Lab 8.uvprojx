# Keil uVision project Lab 8.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab 8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: Lab_8_Code.c lcd_lib_4bit_20b.c
    ../Lab 3 - LCD/: Lab3.c
    ../Lab 1/: lab1_led_cycle.c flashled.c
    ../Lab 7b/: Lab_7b_Code.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.5.0
